Commit message: Refactored for package

File: URDF_models/floating_7dof_manipulator.urdf (robot description, URDF)
Before this commit: robot Chaser_Robot, 9 links, 8 joints
Links:
- link Chaser_Base: geometry collision box size=3.1083 1.6308 1.6308; visual box size=3.1083 1.6308 1.6308
